Commit message: Update scripts

File: Pretrain/urdfs/g1_description/g1_29dof_rev_1_0_with_xhand.urdf (robot description, URDF)
Before this commit: robot g1_29dof_rev_1_0, 73 links, 72 joints
Links:
- removed link pelvis
- added link base, mass 3.813; visual mesh filename=meshes/pelvis.STL
